# Keil uVision project MOTOR_ESC_COONNECT.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MOTOR_ESC_COONNECT
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\LIB\inc;..\LINK_OUT\ADC;..\LINK_OUT\CAN;..\LINK_OUT\EXTI;..\LINK_OUT\MOTOR_2104;..\LINK_OUT\TIM;..\LINK_OUT\KEY;..\LINK_OUT\LED;..\LINK_OUT\CAP;..\LINK_OUT\PID;..\LINK_OUT\24C02;..\LINK_OUT\IIC;..\LINK_OUT\uart
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group LINK_OUT
    ../LINK_OUT/ADC/: ADC.c
    ../LINK_OUT/KEY/: KEY.c
    ../LINK_OUT/CAN/: CAN.c
    ../LINK_OUT/EXTI/: EXTI.c
    ../LINK_OUT/MOTOR_2104/: MOTOR.c
    ../LINK_OUT/LED/: LED.c
    ../LINK_OUT/TIM/: TIM.c
    ../LINK_OUT/CAP/: CAP.c
    ../LINK_OUT/24C02/: 24C02.c
    ../LINK_OUT/PID/: PID.c
    ../LINK_OUT/uart/: UART.c
    ../LINK_OUT/IIC/: IIC.c
  group LIB
    ../LIB/src/: stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c
